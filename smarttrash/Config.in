## smarttrash/Config.in
```kconfig
config BR2_PACKAGE_SMARTTRASH
    bool "SMARTTRASH Application"
    help
      Simple application to SMARTTRASH.
      
```
